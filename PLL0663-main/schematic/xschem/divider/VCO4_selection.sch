v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 2030 -2810 2030 -2470 {}
L 4 2200 -2810 2540 -2810 {}
L 4 2520 -2810 2860 -2810 {}
L 4 2230 -2810 2570 -2810 {}
L 4 2570 -2810 2910 -2810 {}
L 4 2200 -2350 2540 -2350 {}
L 4 2520 -2350 2860 -2350 {}
L 4 3120 -2810 3120 -2470 {}
L 4 2030 -2690 2030 -2350 {}
L 4 2030 -2350 2370 -2350 {}
L 4 2030 -2810 2370 -2810 {}
L 4 3120 -2690 3120 -2350 {}
L 4 2720 -2350 3060 -2350 {}
L 4 2720 -2810 3060 -2810 {}
L 4 2780 -2350 3120 -2350 {}
L 4 2780 -2810 3120 -2810 {}
T {VCO4 selection} 2060 -2840 0 0 0.4 0.4 {}
N 1770 -2880 1790 -2880 {lab=gd}
N 1770 -2860 1790 -2860 {lab=VP}
N 1770 -2760 1790 -2760 {lab=000000_n}
N 1780 -2410 1800 -2410 {lab=VCO4_5_sel}
N 1780 -2430 1800 -2430 {lab=VCO4_11_sel}
N 1770 -2720 1790 -2720 {lab=000}
N 1770 -2700 1790 -2700 {lab=000000}
N 1770 -2680 1790 -2680 {lab=after_001111_n}
N 1770 -2660 1790 -2660 {lab=010}
N 1770 -2630 1790 -2630 {lab=after_000011_n}
N 1770 -2610 1790 -2610 {lab=011}
N 1770 -2590 1790 -2590 {lab=001}
N 1770 -2570 1790 -2570 {lab=after_000011}
N 1770 -2550 1790 -2550 {lab=after_000111_n}
N 2480 -2760 2500 -2760 {lab=gd}
N 2480 -2780 2500 -2780 {lab=VP}
N 2480 -2740 2590 -2740 {lab=#net1}
N 2160 -2780 2180 -2780 {lab=000}
N 2160 -2740 2180 -2740 {lab=after_001111_n}
N 2160 -2760 2180 -2760 {lab=after_000011}
N 2480 -2600 2500 -2600 {lab=gd}
N 2480 -2620 2500 -2620 {lab=VP}
N 2480 -2580 2550 -2580 {lab=#net2}
N 2160 -2620 2180 -2620 {lab=010}
N 2160 -2580 2180 -2580 {lab=000000_n}
N 2160 -2600 2180 -2600 {lab=after_000011_n}
N 2480 -2520 2500 -2520 {lab=gd}
N 2480 -2540 2500 -2540 {lab=VP}
N 2480 -2500 2570 -2500 {lab=#net3}
N 2160 -2540 2180 -2540 {lab=011}
N 2160 -2520 2180 -2520 {lab=000000}
N 2480 -2680 2500 -2680 {lab=gd}
N 2480 -2700 2500 -2700 {lab=VP}
N 2480 -2660 2530 -2660 {lab=#net4}
N 2160 -2700 2180 -2700 {lab=001}
N 2160 -2660 2180 -2660 {lab=Z}
N 2480 -2440 2500 -2440 {lab=gd}
N 2480 -2460 2500 -2460 {lab=VP}
N 2550 -2390 2550 -2380 {lab=gd}
N 2550 -2460 2550 -2450 {lab=VP}
N 2480 -2420 2530 -2420 {lab=#net5}
N 2600 -2420 2680 -2420 {lab=VCO4_11_sel}
N 2160 -2460 2180 -2460 {lab=001}
N 2160 -2440 2180 -2440 {lab=after_000011_n}
N 2890 -2720 2910 -2720 {lab=gd}
N 2890 -2740 2910 -2740 {lab=VP}
N 2890 -2700 2940 -2700 {lab=VCO4_5_sel}
N 2160 -2680 2180 -2680 {lab=after_000111_n}
N 2530 -2720 2530 -2660 {lab=#net4}
N 2530 -2720 2590 -2720 {lab=#net4}
N 2550 -2700 2590 -2700 {lab=#net2}
N 2550 -2700 2550 -2580 {lab=#net2}
N 2570 -2680 2570 -2500 {lab=#net3}
N 2570 -2680 2590 -2680 {lab=#net3}
N 3050 -2600 3070 -2600 {lab=gd}
N 3050 -2620 3070 -2620 {lab=VP}
N 3050 -2500 3070 -2500 {lab=gd}
N 3050 -2520 3070 -2520 {lab=VP}
N 3050 -2580 3050 -2550 {lab=nand_f1_f0}
N 2750 -2550 3050 -2550 {lab=nand_f1_f0}
N 2750 -2550 2750 -2520 {lab=nand_f1_f0}
N 3050 -2480 3070 -2480 {lab=Z}
N 2720 -2500 2750 -2500 {lab=after_000011_n}
N 2730 -2620 2750 -2620 {lab=f1}
N 2730 -2600 2750 -2600 {lab=f0}
N 2720 -2550 2750 -2550 {lab=nand_f1_f0}
N 2160 -2420 2180 -2420 {lab=nand_f1_f0}
N 1780 -2370 1800 -2370 {lab=f1}
N 1780 -2350 1800 -2350 {lab=f0}
C {iopin.sym} 1770 -2880 2 0 {name=p46 lab=gd}
C {lab_wire.sym} 1790 -2880 2 0 {name=p53 sig_type=std_logic lab=gd}
C {iopin.sym} 1770 -2860 2 0 {name=p54 lab=VP}
C {ipin.sym} 1770 -2760 0 0 {name=p59 lab=000000_n}
C {lab_wire.sym} 1790 -2760 2 0 {name=p60 sig_type=std_logic lab=000000_n}
C {lab_wire.sym} 1790 -2860 2 0 {name=p1 sig_type=std_logic lab=VP}
C {opin.sym} 1780 -2410 0 1 {name=p6 lab=VCO4_5_sel}
C {lab_wire.sym} 1800 -2410 2 0 {name=p7 sig_type=std_logic lab=VCO4_5_sel}
C {opin.sym} 1780 -2430 0 1 {name=p14 lab=VCO4_11_sel}
C {lab_wire.sym} 1800 -2430 2 0 {name=p15 sig_type=std_logic lab=VCO4_11_sel}
C {ipin.sym} 1770 -2720 0 0 {name=p19 lab=000
}
C {lab_wire.sym} 1790 -2720 2 0 {name=p22 sig_type=std_logic lab=000}
C {ipin.sym} 1770 -2700 0 0 {name=p23 lab=000000
}
C {lab_wire.sym} 1790 -2700 2 0 {name=p24 sig_type=std_logic lab=000000}
C {ipin.sym} 1770 -2680 0 0 {name=p25 lab=after_001111_n}
C {lab_wire.sym} 1790 -2680 2 0 {name=p26 sig_type=std_logic lab=after_001111_n}
C {ipin.sym} 1770 -2660 0 0 {name=p27 lab=010}
C {lab_wire.sym} 1790 -2660 2 0 {name=p28 sig_type=std_logic lab=010}
C {ipin.sym} 1770 -2630 0 0 {name=p2 lab=after_000011_n}
C {lab_wire.sym} 1790 -2630 2 0 {name=p3 sig_type=std_logic lab=after_000011_n}
C {ipin.sym} 1770 -2610 0 0 {name=p4 lab=011}
C {lab_wire.sym} 1790 -2610 2 0 {name=p5 sig_type=std_logic lab=011}
C {ipin.sym} 1770 -2590 0 0 {name=p8 lab=001
}
C {lab_wire.sym} 1790 -2590 2 0 {name=p9 sig_type=std_logic lab=001}
C {ipin.sym} 1770 -2570 0 0 {name=p10 lab=after_000011}
C {lab_wire.sym} 1790 -2570 2 0 {name=p11 sig_type=std_logic lab=after_000011}
C {ipin.sym} 1770 -2550 0 0 {name=p12 lab=after_000111_n}
C {lab_wire.sym} 1790 -2550 2 0 {name=p13 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 2500 -2780 2 0 {name=p16 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2500 -2760 2 0 {name=p17 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2500 -2620 2 0 {name=p18 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2500 -2600 2 0 {name=p20 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2500 -2540 2 0 {name=p21 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2500 -2520 2 0 {name=p29 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2500 -2700 2 0 {name=p30 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2500 -2680 2 0 {name=p31 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2500 -2460 2 0 {name=p32 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2500 -2440 2 0 {name=p33 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2550 -2460 0 1 {name=p34 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2550 -2380 2 0 {name=p35 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2160 -2780 0 0 {name=p36 sig_type=std_logic lab=000}
C {lab_wire.sym} 2160 -2620 0 0 {name=p37 sig_type=std_logic lab=010}
C {lab_wire.sym} 2160 -2540 0 0 {name=p38 sig_type=std_logic lab=011}
C {lab_wire.sym} 2160 -2700 0 0 {name=p39 sig_type=std_logic lab=001}
C {lab_wire.sym} 2680 -2420 2 0 {name=p40 sig_type=std_logic lab=VCO4_11_sel}
C {lab_wire.sym} 2160 -2740 0 0 {name=p41 sig_type=std_logic lab=after_001111_n}
C {lab_wire.sym} 2160 -2760 0 0 {name=p42 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 2160 -2600 0 0 {name=p43 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2160 -2460 0 0 {name=p44 sig_type=std_logic lab=001}
C {lab_wire.sym} 2160 -2440 0 0 {name=p45 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2910 -2740 2 0 {name=p47 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2910 -2720 2 0 {name=p48 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2940 -2700 2 0 {name=p49 sig_type=std_logic lab=VCO4_5_sel}
C {lab_wire.sym} 2160 -2680 0 0 {name=p50 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 2160 -2520 0 0 {name=p51 sig_type=std_logic lab=000000}
C {lab_wire.sym} 2160 -2580 0 0 {name=p52 sig_type=std_logic lab=000000_n}
C {lab_wire.sym} 3070 -2620 2 0 {name=p55 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3070 -2600 2 0 {name=p199 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3070 -2520 2 0 {name=p200 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3070 -2500 2 0 {name=p207 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3070 -2480 2 0 {name=p208 sig_type=std_logic lab=Z}
C {lab_wire.sym} 2160 -2660 0 0 {name=p209 sig_type=std_logic lab=Z}
C {lab_wire.sym} 2720 -2500 0 0 {name=p210 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2730 -2620 0 0 {name=p211 sig_type=std_logic lab=f1}
C {lab_wire.sym} 2730 -2600 0 0 {name=p212 sig_type=std_logic lab=f0}
C {lab_wire.sym} 2720 -2550 0 0 {name=p214 sig_type=std_logic lab=nand_f1_f0}
C {lab_wire.sym} 2160 -2420 0 0 {name=p215 sig_type=std_logic lab=nand_f1_f0}
C {lab_wire.sym} 1800 -2370 2 0 {name=p56 sig_type=std_logic lab=f1}
C {lab_wire.sym} 1800 -2350 2 0 {name=p57 sig_type=std_logic lab=f0}
C {ipin.sym} 1780 -2370 0 0 {name=p58 lab=f1}
C {ipin.sym} 1780 -2350 0 0 {name=p61 lab=f0}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_3in_dek.sym} 2330 -2440 0 0 {name=x1}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_3in_dek.sym} 2330 -2600 0 0 {name=x2}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_3in_dek.sym} 2330 -2680 0 0 {name=x3}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_3in_dek.sym} 2330 -2760 0 0 {name=x4}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_2in_dek.sym} 2330 -2520 0 0 {name=x7}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_2in_dek.sym} 2900 -2600 0 0 {name=x8}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_2in_dek.sym} 2900 -2500 0 0 {name=x9}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/inverter_dek.sym} 2550 -2420 0 0 {name=x5}
C {/foss/designs/CHIP-PLL/PLL0663-main/schematic/xschem/divider/NAND_4in_dek.sym} 2740 -2710 0 0 {name=x6}
