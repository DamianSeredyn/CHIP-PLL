v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 -160 -190 -160 150 {}
L 4 -160 -190 340 -190 {}
L 4 340 -190 340 150 {}
L 4 -160 150 340 150 {}
L 4 60 -280 400 -280 {}
L 4 400 -280 740 -280 {}
L 4 -160 -280 180 -280 {}
L 4 -160 -620 -160 -280 {}
L 4 -160 -1020 -160 -680 {}
L 4 850 -700 850 -360 {}
L 4 850 -1020 850 -680 {}
L 4 510 -280 850 -280 {}
L 4 60 -1020 400 -1020 {}
L 4 400 -1020 740 -1020 {}
L 4 -160 -1020 180 -1020 {}
L 4 510 -1020 850 -1020 {}
L 4 -160 -900 -160 -560 {}
L 4 850 -620 850 -280 {}
L 4 890 -1010 890 -670 {}
L 4 890 -670 1230 -670 {}
L 4 1230 -670 1570 -670 {}
L 4 1570 -670 1910 -670 {}
L 4 1910 -1010 1910 -670 {}
L 4 890 -1010 1230 -1010 {}
L 4 1230 -1010 1570 -1010 {}
L 4 1570 -1010 1910 -1010 {}
L 4 890 -600 890 -260 {}
L 4 890 -600 1230 -600 {}
L 4 1230 -600 1570 -600 {}
L 4 1570 -600 1910 -600 {}
L 4 890 -270 890 70 {}
L 4 890 -110 890 230 {}
L 4 890 220 890 560 {}
L 4 890 610 1230 610 {}
L 4 1230 610 1570 610 {}
L 4 1570 610 1910 610 {}
L 4 890 270 890 610 {}
L 4 1900 -600 2240 -600 {}
L 4 2460 270 2460 610 {}
L 4 1890 610 2230 610 {}
L 4 2120 610 2460 610 {}
L 4 2460 -60 2460 280 {}
L 4 2460 -400 2460 -60 {}
L 4 2460 -600 2460 -260 {}
L 4 2120 -600 2460 -600 {}
L 4 2470 -200 2470 140 {}
L 4 2470 -530 2470 -190 {}
L 4 2470 -870 2470 -530 {}
L 4 2470 -1070 2470 -730 {}
L 4 2470 270 2470 610 {}
L 4 2470 -60 2470 280 {}
L 4 2470 -400 2470 -60 {}
L 4 2470 -600 2470 -260 {}
L 4 4030 -870 4030 -530 {}
L 4 4030 -1070 4030 -730 {}
L 4 4030 270 4030 610 {}
L 4 4030 -60 4030 280 {}
L 4 4030 -400 4030 -60 {}
L 4 4030 -600 4030 -260 {}
L 4 2470 -1070 2810 -1070 {}
L 4 2810 -1070 3150 -1070 {}
L 4 3140 -1070 3480 -1070 {}
L 4 3360 -1070 3700 -1070 {}
L 4 2800 -1070 3140 -1070 {}
L 4 3140 -1070 3480 -1070 {}
L 4 3470 -1070 3810 -1070 {}
L 4 3690 -1070 4030 -1070 {}
L 4 2470 610 2810 610 {}
L 4 2800 610 3140 610 {}
L 4 3140 610 3480 610 {}
L 4 3470 610 3810 610 {}
L 4 3690 610 4030 610 {}
L 4 890 1000 890 1340 {}
L 4 890 660 890 1000 {}
L 4 890 660 1230 660 {}
L 4 1230 660 1570 660 {}
L 4 1570 660 1910 660 {}
L 4 1890 660 2230 660 {}
L 4 1600 660 1940 660 {}
L 4 1940 660 2280 660 {}
L 4 2280 660 2620 660 {}
L 4 2600 660 2940 660 {}
L 4 890 1460 1230 1460 {}
L 4 1230 1460 1570 1460 {}
L 4 1570 1460 1910 1460 {}
L 4 1890 1460 2230 1460 {}
L 4 2280 1460 2620 1460 {}
L 4 2600 1460 2940 1460 {}
L 4 2140 1460 2480 1460 {}
L 4 890 1120 890 1460 {}
L 4 2940 1000 2940 1340 {}
L 4 2940 660 2940 1000 {}
L 4 2940 1120 2940 1460 {}
L 4 2980 710 2980 1050 {}
L 4 2980 660 2980 1000 {}
L 4 2980 660 3320 660 {}
L 4 3300 660 3640 660 {}
L 4 3630 660 3970 660 {}
L 4 3950 660 4290 660 {}
L 4 2980 1050 3320 1050 {}
L 4 3300 1050 3640 1050 {}
L 4 3630 1050 3970 1050 {}
L 4 3950 1050 4290 1050 {}
L 4 4450 710 4450 1050 {}
L 4 4450 660 4450 1000 {}
L 4 4110 660 4450 660 {}
L 4 4110 1050 4450 1050 {}
T {Column decoding} -160 -220 0 0 0.4 0.4 {}
T {Row section decoding} -160 -1060 0 0 0.4 0.4 {}
T {VCO selection} 890 -1050 0 0 0.4 0.4 {}
T {VCO2 selection} 890 -640 0 0 0.4 0.4 {}
T {VCO3 selection} 2470 -1110 0 0 0.4 0.4 {}
T {VCO4 selection} 890 630 0 0 0.4 0.4 {}
T {VCO5 selection} 2980 630 0 0 0.4 0.4 {}
N 640 -200 660 -200 {lab=gd}
N 640 -180 660 -180 {lab=VP}
N 640 -130 660 -130 {lab=c1}
N 640 -110 660 -110 {lab=c2}
N 640 -80 660 -80 {lab=f0}
N 640 -60 660 -60 {lab=f1}
N 640 -150 660 -150 {lab=c0}
N 640 80 660 80 {lab=VCO2_11_sel}
N 640 100 660 100 {lab=VCO2_5_sel}
N 640 60 660 60 {lab=VCO_sel}
N 640 120 660 120 {lab=VCO3_11_sel}
N 640 140 660 140 {lab=VCO3_5_sel}
N 640 180 660 180 {lab=VCO4_5_sel}
N 640 200 660 200 {lab=VCO5_11_sel}
N 640 160 660 160 {lab=VCO4_11_sel}
N 640 -40 660 -40 {lab=f2}
N 640 -20 660 -20 {lab=f3}
N 640 0 660 0 {lab=f4}
N 640 20 660 20 {lab=f5}
N -120 -90 -100 -90 {lab=c1}
N -120 -70 -100 -70 {lab=c2}
N -120 -110 -100 -110 {lab=c0}
N 200 -90 220 -90 {lab=VP}
N 200 -110 220 -110 {lab=gd}
N 230 -930 250 -930 {lab=gd}
N 230 -950 250 -950 {lab=VP}
N 230 -840 250 -840 {lab=gd}
N 230 -860 250 -860 {lab=VP}
N 230 -690 250 -690 {lab=gd}
N 230 -710 250 -710 {lab=VP}
N 230 -500 250 -500 {lab=gd}
N 230 -520 250 -520 {lab=VP}
N 230 -910 300 -910 {lab=#net1}
N 300 -890 300 -820 {lab=#net2}
N 230 -820 300 -820 {lab=#net2}
N 600 -890 620 -890 {lab=gd}
N 600 -910 620 -910 {lab=VP}
N 300 -640 300 -620 {lab=gd}
N 300 -720 300 -700 {lab=VP}
N 260 -670 280 -670 {lab=after_000111_n}
N 260 -670 260 -590 {lab=after_000111_n}
N 230 -670 260 -670 {lab=after_000111_n}
N 260 -590 360 -590 {lab=after_000111_n}
N 300 -450 300 -430 {lab=gd}
N 300 -530 300 -510 {lab=VP}
N 260 -480 280 -480 {lab=after_001111_n}
N 260 -480 260 -400 {lab=after_001111_n}
N 230 -480 260 -480 {lab=after_001111_n}
N 260 -400 360 -400 {lab=after_001111_n}
N 350 -480 360 -480 {lab=after_001111}
N 350 -670 360 -670 {lab=after_000111}
N -90 -950 -70 -950 {lab=f2}
N -90 -930 -70 -930 {lab=f3}
N -90 -860 -70 -860 {lab=f4}
N -90 -840 -70 -840 {lab=f5}
N -90 -710 -70 -710 {lab=f3}
N -90 -690 -70 -690 {lab=f4}
N -90 -670 -70 -670 {lab=f5}
N -90 -520 -70 -520 {lab=f4}
N -90 -500 -70 -500 {lab=f5}
N 610 -870 700 -870 {lab=after_000011}
N 640 -760 640 -740 {lab=gd}
N 640 -840 640 -820 {lab=VP}
N 690 -790 700 -790 {lab=after_000011_n}
N 610 -870 610 -790 {lab=after_000011}
N 600 -870 610 -870 {lab=after_000011}
N 610 -790 620 -790 {lab=after_000011}
N 640 -590 640 -570 {lab=gd}
N 640 -670 640 -650 {lab=VP}
N 600 -620 620 -620 {lab=f1}
N 690 -620 700 -620 {lab=f1_n}
N 640 -420 640 -400 {lab=gd}
N 640 -500 640 -480 {lab=VP}
N 600 -450 620 -450 {lab=f5}
N 690 -450 700 -450 {lab=f5_n}
N 1340 -890 1360 -890 {lab=gd}
N 1340 -910 1360 -910 {lab=VP}
N 1340 -810 1360 -810 {lab=gd}
N 1340 -830 1360 -830 {lab=VP}
N 1340 -730 1360 -730 {lab=gd}
N 1340 -750 1360 -750 {lab=VP}
N 200 -70 230 -70 {lab=000}
N 200 -50 230 -50 {lab=001}
N 200 -30 230 -30 {lab=010}
N 200 -10 230 -10 {lab=011}
N 200 10 230 10 {lab=100}
N 200 30 230 30 {lab=101}
N 200 50 230 50 {lab=110}
N 200 70 230 70 {lab=111}
N 1020 -910 1040 -910 {lab=after_000111}
N 1020 -890 1040 -890 {lab=111}
N 1020 -830 1040 -830 {lab=after_001111}
N 1020 -810 1040 -810 {lab=110}
N 1020 -750 1040 -750 {lab=101}
N 1020 -730 1040 -730 {lab=f5}
N 1340 -870 1460 -870 {lab=#net3}
N 1400 -850 1460 -850 {lab=#net4}
N 1400 -850 1400 -790 {lab=#net4}
N 1340 -790 1400 -790 {lab=#net4}
N 1420 -830 1460 -830 {lab=#net5}
N 1340 -710 1420 -710 {lab=#net5}
N 1420 -830 1420 -710 {lab=#net5}
N 1760 -850 1780 -850 {lab=gd}
N 1760 -870 1780 -870 {lab=VP}
N 1760 -830 1810 -830 {lab=VCO_sel}
N 1340 -550 1360 -550 {lab=gd}
N 1340 -570 1360 -570 {lab=VP}
N 1340 -390 1360 -390 {lab=gd}
N 1340 -410 1360 -410 {lab=VP}
N 1340 -470 1360 -470 {lab=gd}
N 1340 -490 1360 -490 {lab=VP}
N 1340 -310 1360 -310 {lab=gd}
N 1340 -330 1360 -330 {lab=VP}
N 1020 -570 1040 -570 {lab=110}
N 1020 -550 1040 -550 {lab=after_001111_n}
N 1020 -530 1040 -530 {lab=after_000111}
N 1020 -490 1040 -490 {lab=101}
N 1020 -470 1040 -470 {lab=after_000111}
N 1020 -450 1040 -450 {lab=f5_n}
N 1020 -330 1040 -330 {lab=111}
N 1020 -290 1040 -290 {lab=after_000111_n}
N 1020 -410 1040 -410 {lab=100}
N 1020 -390 1040 -390 {lab=f5}
N 1340 -530 1440 -530 {lab=#net6}
N 1340 -450 1400 -450 {lab=#net7}
N 1400 -510 1400 -450 {lab=#net7}
N 1400 -510 1440 -510 {lab=#net7}
N 1420 -490 1440 -490 {lab=#net8}
N 1420 -490 1420 -370 {lab=#net8}
N 1340 -370 1420 -370 {lab=#net8}
N 1340 -290 1440 -290 {lab=#net9}
N 1440 -470 1440 -290 {lab=#net9}
N 1740 -510 1760 -510 {lab=gd}
N 1740 -530 1760 -530 {lab=VP}
N 1740 -490 1790 -490 {lab=VCO2_5_sel}
N 1850 10 1870 10 {lab=gd}
N 1850 -10 1870 -10 {lab=VP}
N 1850 80 1870 80 {lab=gd}
N 1850 60 1870 60 {lab=VP}
N 1850 150 1870 150 {lab=gd}
N 1850 130 1870 130 {lab=VP}
N 2230 50 2250 50 {lab=gd}
N 2230 30 2250 30 {lab=VP}
N 1850 30 1930 30 {lab=#net10}
N 1850 100 1900 100 {lab=#net11}
N 1900 50 1900 100 {lab=#net11}
N 1900 50 1930 50 {lab=#net11}
N 1920 70 1930 70 {lab=#net12}
N 1920 70 1920 170 {lab=#net12}
N 1850 170 1920 170 {lab=#net12}
N 1340 -200 1360 -200 {lab=gd}
N 1340 -220 1360 -220 {lab=VP}
N 1340 -80 1360 -80 {lab=gd}
N 1340 -100 1360 -100 {lab=VP}
N 1410 -150 1410 -140 {lab=gd}
N 1410 -220 1410 -210 {lab=VP}
N 1340 -180 1390 -180 {lab=#net13}
N 1460 -180 1540 -180 {lab=#net14}
N 1410 -30 1410 -20 {lab=gd}
N 1410 -100 1410 -90 {lab=VP}
N 1340 -60 1390 -60 {lab=#net15}
N 1460 -60 1530 -60 {lab=#net16}
N 1340 40 1360 40 {lab=gd}
N 1340 20 1360 20 {lab=VP}
N 1410 90 1410 100 {lab=gd}
N 1410 20 1410 30 {lab=VP}
N 1340 60 1390 60 {lab=#net17}
N 1460 60 1550 60 {lab=#net18}
N 1340 160 1360 160 {lab=gd}
N 1340 140 1360 140 {lab=VP}
N 1410 210 1410 220 {lab=gd}
N 1410 140 1410 150 {lab=VP}
N 1340 180 1390 180 {lab=#net19}
N 1460 180 1470 180 {lab=#net20}
N 1340 280 1360 280 {lab=gd}
N 1340 260 1360 260 {lab=VP}
N 1410 330 1410 340 {lab=gd}
N 1410 260 1410 270 {lab=VP}
N 1340 300 1390 300 {lab=#net21}
N 1460 300 1510 300 {lab=#net22}
N 1830 390 1850 390 {lab=gd}
N 1830 370 1850 370 {lab=VP}
N 1900 440 1900 450 {lab=gd}
N 1900 370 1900 380 {lab=VP}
N 1830 410 1880 410 {lab=#net23}
N 1950 410 1970 410 {lab=#net24}
N 1830 510 1850 510 {lab=gd}
N 1830 490 1850 490 {lab=VP}
N 1900 560 1900 570 {lab=gd}
N 1900 490 1900 500 {lab=VP}
N 1830 530 1880 530 {lab=#net25}
N 1950 530 1960 530 {lab=#net26}
N 1540 -10 1550 -10 {lab=#net14}
N 1540 -180 1540 -10 {lab=#net14}
N 1530 -60 1530 10 {lab=#net16}
N 1530 10 1550 10 {lab=#net16}
N 1470 80 1470 180 {lab=#net20}
N 1470 80 1550 80 {lab=#net20}
N 1510 130 1510 300 {lab=#net22}
N 1510 130 1550 130 {lab=#net22}
N 2270 430 2290 430 {lab=gd}
N 2270 410 2290 410 {lab=VP}
N 2340 480 2340 490 {lab=gd}
N 2340 410 2340 420 {lab=VP}
N 2270 450 2320 450 {lab=#net27}
N 2390 450 2400 450 {lab=#net28}
N 1960 430 1970 430 {lab=#net26}
N 1960 430 1960 530 {lab=#net26}
N 1530 150 1530 300 {lab=#net28}
N 1530 150 1550 150 {lab=#net28}
N 1340 390 1360 390 {lab=gd}
N 1340 370 1360 370 {lab=VP}
N 2400 300 2400 450 {lab=#net28}
N 1530 300 2400 300 {lab=#net28}
N 1020 -310 1040 -310 {lab=after_000011}
N 1020 -220 1040 -220 {lab=100}
N 1020 -180 1040 -180 {lab=f5_n}
N 1020 -200 1040 -200 {lab=after_000111}
N 1020 260 1040 260 {lab=101}
N 1020 300 1040 300 {lab=after_000111_n}
N 1020 280 1040 280 {lab=after_000011}
N 1510 490 1530 490 {lab=110}
N 1510 530 1530 530 {lab=after_000111_n}
N 1510 510 1530 510 {lab=after_000011}
N 1020 370 1040 370 {lab=f0}
N 1020 390 1040 390 {lab=f1}
N 1510 370 1530 370 {lab=110}
N 1510 390 1530 390 {lab=after_000011_n}
N 1020 20 1040 20 {lab=010}
N 1020 40 1040 40 {lab=f5}
N 1020 -100 1040 -100 {lab=011}
N 1020 -80 1040 -80 {lab=after_001111}
N 1020 140 1040 140 {lab=111}
N 1020 160 1040 160 {lab=after_000011_n}
N 1340 410 1530 410 {lab=#net29}
N 2230 70 2250 70 {lab=VCO2_11_sel}
N 3420 970 3440 970 {lab=gd}
N 3420 950 3440 950 {lab=VP}
N 3100 950 3120 950 {lab=010}
N 3100 990 3120 990 {lab=f1_n}
N 3100 970 3120 970 {lab=after_000011_n}
N 3420 850 3440 850 {lab=gd}
N 3420 830 3440 830 {lab=VP}
N 3490 900 3490 910 {lab=gd}
N 3490 830 3490 840 {lab=VP}
N 3420 870 3470 870 {lab=#net30}
N 3540 870 3620 870 {lab=#net31}
N 3100 830 3120 830 {lab=000}
N 3100 850 3120 850 {lab=after_000011_n}
N 2950 -1000 2970 -1000 {lab=gd}
N 2950 -1020 2970 -1020 {lab=VP}
N 3020 -950 3020 -940 {lab=gd}
N 3020 -1020 3020 -1010 {lab=VP}
N 2950 -980 3000 -980 {lab=#net32}
N 3070 -980 3200 -980 {lab=#net33}
N 2630 -1020 2650 -1020 {lab=011}
N 2630 -980 2650 -980 {lab=after_001111_n}
N 2630 -1000 2650 -1000 {lab=after_000111}
N 2950 -880 2970 -880 {lab=gd}
N 2950 -900 2970 -900 {lab=VP}
N 3020 -830 3020 -820 {lab=gd}
N 3020 -900 3020 -890 {lab=VP}
N 2950 -860 3000 -860 {lab=#net34}
N 3070 -860 3160 -860 {lab=#net35}
N 2630 -900 2650 -900 {lab=010}
N 2630 -860 2650 -860 {lab=f5_n}
N 2630 -880 2650 -880 {lab=after_000111}
N 2950 -760 2970 -760 {lab=gd}
N 2950 -780 2970 -780 {lab=VP}
N 3020 -710 3020 -700 {lab=gd}
N 3020 -780 3020 -770 {lab=VP}
N 2950 -740 3000 -740 {lab=#net36}
N 3070 -740 3150 -740 {lab=#net37}
N 2630 -780 2650 -780 {lab=001}
N 2630 -760 2650 -760 {lab=f5_n}
N 2950 -640 2970 -640 {lab=gd}
N 2950 -660 2970 -660 {lab=VP}
N 3020 -590 3020 -580 {lab=gd}
N 3020 -660 3020 -650 {lab=VP}
N 2950 -620 3000 -620 {lab=#net38}
N 3070 -620 3150 -620 {lab=#net39}
N 2630 -660 2650 -660 {lab=101}
N 2630 -640 2650 -640 {lab=after_000011_n}
N 2950 -520 2970 -520 {lab=gd}
N 2950 -540 2970 -540 {lab=VP}
N 3020 -470 3020 -460 {lab=gd}
N 3020 -540 3020 -530 {lab=VP}
N 2950 -500 3000 -500 {lab=#net40}
N 3070 -500 3170 -500 {lab=#net41}
N 2630 -540 2650 -540 {lab=100}
N 2630 -500 2650 -500 {lab=after_000111_n}
N 2630 -520 2650 -520 {lab=after_000011}
N 2950 -400 2970 -400 {lab=gd}
N 2950 -420 2970 -420 {lab=VP}
N 3020 -350 3020 -340 {lab=gd}
N 3020 -420 3020 -410 {lab=VP}
N 2950 -380 3000 -380 {lab=#net42}
N 2630 -420 2650 -420 {lab=110}
N 2630 -380 2650 -380 {lab=#net43}
N 2630 -400 2650 -400 {lab=after_000011_n}
N 3530 -750 3550 -750 {lab=gd}
N 3530 -770 3550 -770 {lab=VP}
N 3530 -680 3550 -680 {lab=gd}
N 3530 -700 3550 -700 {lab=VP}
N 3530 -610 3550 -610 {lab=gd}
N 3530 -630 3550 -630 {lab=VP}
N 3910 -710 3930 -710 {lab=gd}
N 3910 -730 3930 -730 {lab=VP}
N 3530 -730 3610 -730 {lab=#net44}
N 3530 -660 3580 -660 {lab=#net45}
N 3580 -710 3580 -660 {lab=#net45}
N 3580 -710 3610 -710 {lab=#net45}
N 3600 -690 3610 -690 {lab=#net46}
N 3600 -690 3600 -590 {lab=#net46}
N 3530 -590 3600 -590 {lab=#net46}
N 3910 -690 3930 -690 {lab=VCO3_5_sel}
N 3150 -700 3230 -700 {lab=#net37}
N 3150 -740 3150 -700 {lab=#net37}
N 3150 -680 3230 -680 {lab=#net39}
N 3150 -680 3150 -620 {lab=#net39}
N 3170 -630 3230 -630 {lab=#net41}
N 3170 -630 3170 -500 {lab=#net41}
N 3070 -380 3190 -380 {lab=#net47}
N 3190 -610 3190 -380 {lab=#net47}
N 3190 -610 3230 -610 {lab=#net47}
N 3160 -750 3230 -750 {lab=#net35}
N 3160 -860 3160 -750 {lab=#net35}
N 3200 -980 3200 -770 {lab=#net33}
N 3200 -770 3230 -770 {lab=#net33}
N 2950 -270 2970 -270 {lab=gd}
N 2950 -290 2970 -290 {lab=VP}
N 3020 -220 3020 -210 {lab=gd}
N 3020 -290 3020 -280 {lab=VP}
N 2950 -250 3000 -250 {lab=#net48}
N 3070 -250 3090 -250 {lab=#net43}
N 3090 -320 3090 -250 {lab=#net43}
N 2630 -320 3090 -320 {lab=#net43}
N 2630 -380 2630 -320 {lab=#net43}
N 2630 -290 2650 -290 {lab=f0}
N 2630 -270 2650 -270 {lab=f1}
N 3440 370 3460 370 {lab=gd}
N 3440 350 3460 350 {lab=VP}
N 3510 420 3510 430 {lab=gd}
N 3510 350 3510 360 {lab=VP}
N 3440 390 3490 390 {lab=#net49}
N 3560 390 3580 390 {lab=#net50}
N 3440 490 3460 490 {lab=gd}
N 3440 470 3460 470 {lab=VP}
N 3510 540 3510 550 {lab=gd}
N 3510 470 3510 480 {lab=VP}
N 3440 510 3490 510 {lab=#net51}
N 3560 510 3570 510 {lab=#net52}
N 3880 410 3900 410 {lab=gd}
N 3880 390 3900 390 {lab=VP}
N 3880 430 3930 430 {lab=#net53}
N 3570 410 3580 410 {lab=#net52}
N 3570 410 3570 510 {lab=#net52}
N 2950 370 2970 370 {lab=gd}
N 2950 350 2970 350 {lab=VP}
N 3120 470 3140 470 {lab=011}
N 3120 510 3140 510 {lab=after_000111_n}
N 3120 490 3140 490 {lab=after_000011}
N 2630 350 2650 350 {lab=f0}
N 2630 370 2650 370 {lab=f1}
N 3120 350 3140 350 {lab=011}
N 3120 370 3140 370 {lab=after_000011_n}
N 2950 390 3140 390 {lab=#net54}
N 2950 -110 2970 -110 {lab=gd}
N 2950 -130 2970 -130 {lab=VP}
N 3020 -60 3020 -50 {lab=gd}
N 3020 -130 3020 -120 {lab=VP}
N 2950 -90 3000 -90 {lab=#net55}
N 3070 -90 3210 -90 {lab=#net56}
N 2630 -130 2650 -130 {lab=001}
N 2630 -90 2650 -90 {lab=f5_n}
N 2630 -110 2650 -110 {lab=after_000111}
N 2950 10 2970 10 {lab=gd}
N 2950 -10 2970 -10 {lab=VP}
N 3020 60 3020 70 {lab=gd}
N 3020 -10 3020 0 {lab=VP}
N 2950 30 3000 30 {lab=#net57}
N 3070 30 3190 30 {lab=#net58}
N 2630 -10 2650 -10 {lab=000}
N 2630 10 2650 10 {lab=after_001111}
N 2950 130 2970 130 {lab=gd}
N 2950 110 2970 110 {lab=VP}
N 3020 180 3020 190 {lab=gd}
N 3020 110 3020 120 {lab=VP}
N 2950 150 3000 150 {lab=#net59}
N 3070 150 3170 150 {lab=#net60}
N 2630 110 2650 110 {lab=100}
N 2630 130 2650 130 {lab=after_000011_n}
N 2950 250 2970 250 {lab=gd}
N 2950 230 2970 230 {lab=VP}
N 3020 300 3020 310 {lab=gd}
N 3020 230 3020 240 {lab=VP}
N 2950 270 3000 270 {lab=#net61}
N 3070 270 3190 270 {lab=#net62}
N 2630 230 2650 230 {lab=010}
N 2630 270 2650 270 {lab=after_000111_n}
N 2630 250 2650 250 {lab=after_000011}
N 3530 70 3550 70 {lab=gd}
N 3530 50 3550 50 {lab=VP}
N 3530 140 3550 140 {lab=gd}
N 3530 120 3550 120 {lab=VP}
N 3910 110 3930 110 {lab=gd}
N 3910 90 3930 90 {lab=VP}
N 3530 90 3610 90 {lab=#net63}
N 3530 160 3580 160 {lab=#net64}
N 3580 110 3580 160 {lab=#net64}
N 3580 110 3610 110 {lab=#net64}
N 3600 130 3610 130 {lab=#net53}
N 3600 130 3600 240 {lab=#net53}
N 3910 130 3930 130 {lab=VCO3_11_sel}
N 3930 240 3930 430 {lab=#net53}
N 3600 240 3930 240 {lab=#net53}
N 3210 -90 3210 50 {lab=#net56}
N 3210 50 3230 50 {lab=#net56}
N 3190 70 3230 70 {lab=#net58}
N 3190 30 3190 70 {lab=#net58}
N 3170 120 3170 150 {lab=#net60}
N 3170 120 3230 120 {lab=#net60}
N 3190 140 3230 140 {lab=#net62}
N 3190 140 3190 270 {lab=#net62}
N 1850 710 1870 710 {lab=gd}
N 1850 690 1870 690 {lab=VP}
N 1920 760 1920 770 {lab=gd}
N 1920 690 1920 700 {lab=VP}
N 1850 730 1900 730 {lab=#net65}
N 1970 730 2080 730 {lab=#net66}
N 1530 690 1550 690 {lab=000}
N 1530 730 1550 730 {lab=after_001111_n}
N 1530 710 1550 710 {lab=after_000111}
N 1850 840 1870 840 {lab=gd}
N 1850 820 1870 820 {lab=VP}
N 1920 890 1920 900 {lab=gd}
N 1920 820 1920 830 {lab=VP}
N 1850 860 1900 860 {lab=#net67}
N 1970 860 2070 860 {lab=#net68}
N 1530 820 1550 820 {lab=010}
N 1530 860 1550 860 {lab=f1}
N 1530 840 1550 840 {lab=after_000011_n}
N 1850 970 1870 970 {lab=gd}
N 1850 950 1870 950 {lab=VP}
N 1920 1020 1920 1030 {lab=gd}
N 1920 950 1920 960 {lab=VP}
N 1850 990 1900 990 {lab=#net69}
N 1970 990 2060 990 {lab=#net70}
N 1530 950 1550 950 {lab=011}
N 1530 990 1550 990 {lab=after_000011_n}
N 1850 1100 1870 1100 {lab=gd}
N 1850 1080 1870 1080 {lab=VP}
N 1920 1150 1920 1160 {lab=gd}
N 1920 1080 1920 1090 {lab=VP}
N 1850 1120 1900 1120 {lab=#net71}
N 1530 1080 1550 1080 {lab=001}
N 1530 1120 1550 1120 {lab=after_000011_n}
N 1850 1230 1870 1230 {lab=gd}
N 1850 1210 1870 1210 {lab=VP}
N 1920 1280 1920 1290 {lab=gd}
N 1920 1210 1920 1220 {lab=VP}
N 1850 1250 1900 1250 {lab=#net72}
N 1530 1210 1550 1210 {lab=001}
N 1530 1250 1550 1250 {lab=after_000111_n}
N 1530 1230 1550 1230 {lab=after_000011}
N 1850 1360 1870 1360 {lab=gd}
N 1850 1340 1870 1340 {lab=VP}
N 1920 1410 1920 1420 {lab=gd}
N 1920 1340 1920 1350 {lab=VP}
N 1850 1380 1900 1380 {lab=#net73}
N 1970 1380 2050 1380 {lab=VCO4_11_sel}
N 1530 1340 1550 1340 {lab=000}
N 1530 1380 1550 1380 {lab=after_000111_n}
N 1530 1360 1550 1360 {lab=after_000011}
N 2430 890 2450 890 {lab=gd}
N 2430 870 2450 870 {lab=VP}
N 2430 910 2480 910 {lab=#net74}
N 2430 970 2450 970 {lab=gd}
N 2430 950 2450 950 {lab=VP}
N 2430 990 2480 990 {lab=#net75}
N 2110 970 2130 970 {lab=#net76}
N 2480 930 2480 990 {lab=#net75}
N 2780 930 2800 930 {lab=gd}
N 2780 910 2800 910 {lab=VP}
N 2340 1200 2360 1200 {lab=gd}
N 2340 1180 2360 1180 {lab=VP}
N 2410 1250 2410 1260 {lab=gd}
N 2410 1180 2410 1190 {lab=VP}
N 2340 1220 2390 1220 {lab=#net77}
N 2460 1220 2480 1220 {lab=#net76}
N 2040 1120 2040 1180 {lab=#net78}
N 1970 1120 2040 1120 {lab=#net78}
N 2040 1200 2040 1250 {lab=#net79}
N 1970 1250 2040 1250 {lab=#net79}
N 2070 860 2070 890 {lab=#net68}
N 2070 890 2130 890 {lab=#net68}
N 2080 870 2130 870 {lab=#net66}
N 2080 730 2080 870 {lab=#net66}
N 2060 950 2060 990 {lab=#net70}
N 2060 950 2130 950 {lab=#net70}
N 2110 970 2110 1110 {lab=#net76}
N 2110 1110 2480 1110 {lab=#net76}
N 2480 1110 2480 1220 {lab=#net76}
N 2780 950 2840 950 {lab=VCO4_5_sel}
N 1300 1080 1320 1080 {lab=gd}
N 1300 1060 1320 1060 {lab=VP}
N 1300 950 1320 950 {lab=gd}
N 1300 930 1320 930 {lab=VP}
N 1370 1000 1370 1010 {lab=gd}
N 1370 930 1370 940 {lab=VP}
N 1300 970 1350 970 {lab=#net80}
N 980 930 1000 930 {lab=f0}
N 980 950 1000 950 {lab=f1}
N 1300 1100 1550 1100 {lab=#net81}
N 1420 970 1550 970 {lab=#net82}
N 980 1060 1000 1060 {lab=f0}
N 980 1080 1000 1080 {lab=f1}
N 3970 740 3990 740 {lab=gd}
N 3970 720 3990 720 {lab=VP}
N 4040 790 4040 800 {lab=gd}
N 4040 720 4040 730 {lab=VP}
N 3970 760 4020 760 {lab=#net83}
N 3650 720 3670 720 {lab=001}
N 3650 760 3670 760 {lab=after_000011_n}
N 3420 720 3440 720 {lab=gd}
N 3420 700 3440 700 {lab=VP}
N 3490 770 3490 780 {lab=gd}
N 3490 700 3490 710 {lab=VP}
N 3420 740 3470 740 {lab=#net84}
N 3100 700 3120 700 {lab=f0}
N 3100 720 3120 720 {lab=f1}
N 3540 740 3670 740 {lab=#net85}
N 3920 870 3940 870 {lab=gd}
N 3920 850 3940 850 {lab=VP}
N 4280 910 4300 910 {lab=gd}
N 4280 890 4300 890 {lab=VP}
N 4280 930 4330 930 {lab=VCO5_11_sel}
N 3920 890 3980 890 {lab=#net86}
N 3620 910 3980 910 {lab=#net87}
N 3610 850 3620 850 {lab=#net88}
N 3610 820 3610 850 {lab=#net88}
N 3610 820 4110 820 {lab=#net88}
N 4110 760 4110 820 {lab=#net88}
N 4090 760 4110 760 {lab=#net88}
N 3620 910 3620 990 {lab=#net87}
N 3420 990 3620 990 {lab=#net87}
C {iopin.sym} 640 -200 2 0 {name=p46 lab=gd}
C {lab_wire.sym} 660 -200 2 0 {name=p53 sig_type=std_logic lab=gd}
C {iopin.sym} 640 -180 2 0 {name=p54 lab=VP}
C {ipin.sym} 640 -130 0 0 {name=p2 lab=c1}
C {lab_wire.sym} 660 -130 2 0 {name=p56 sig_type=std_logic lab=c1}
C {ipin.sym} 640 -110 0 0 {name=p57 lab=c2}
C {lab_wire.sym} 660 -110 2 0 {name=p58 sig_type=std_logic lab=c2}
C {ipin.sym} 640 -80 0 0 {name=p59 lab=f0}
C {lab_wire.sym} 660 -80 2 0 {name=p60 sig_type=std_logic lab=f0}
C {ipin.sym} 640 -60 0 0 {name=p61 lab=f1}
C {lab_wire.sym} 660 -60 2 0 {name=p63 sig_type=std_logic lab=f1}
C {ipin.sym} 640 -150 0 0 {name=p20 lab=c0}
C {lab_wire.sym} 660 -150 2 0 {name=p21 sig_type=std_logic lab=c0}
C {lab_wire.sym} 660 -180 2 0 {name=p1 sig_type=std_logic lab=VP}
C {opin.sym} 640 80 0 1 {name=p6 lab=VCO2_11_sel}
C {lab_wire.sym} 660 80 2 0 {name=p7 sig_type=std_logic lab=VCO2_11_sel}
C {opin.sym} 640 100 0 1 {name=p8 lab=VCO2_5_sel}
C {lab_wire.sym} 660 100 2 0 {name=p9 sig_type=std_logic lab=VCO2_5_sel}
C {opin.sym} 640 60 0 1 {name=p14 lab=VCO_sel}
C {lab_wire.sym} 660 60 2 0 {name=p15 sig_type=std_logic lab=VCO_sel}
C {opin.sym} 640 120 0 1 {name=p10 lab=VCO3_11_sel}
C {lab_wire.sym} 660 120 2 0 {name=p11 sig_type=std_logic lab=VCO3_11_sel}
C {opin.sym} 640 140 0 1 {name=p12 lab=VCO3_5_sel}
C {lab_wire.sym} 660 140 2 0 {name=p13 sig_type=std_logic lab=VCO3_5_sel}
C {opin.sym} 640 160 0 1 {name=p3 lab=VCO4_11_sel}
C {lab_wire.sym} 660 160 2 0 {name=p4 sig_type=std_logic lab=VCO4_11_sel}
C {opin.sym} 640 180 0 1 {name=p5 lab=VCO4_5_sel}
C {lab_wire.sym} 660 180 2 0 {name=p16 sig_type=std_logic lab=VCO4_5_sel}
C {opin.sym} 640 200 0 1 {name=p17 lab=VCO5_11_sel}
C {lab_wire.sym} 660 200 2 0 {name=p18 sig_type=std_logic lab=VCO5_11_sel}
C {ipin.sym} 640 -40 0 0 {name=p19 lab=f2}
C {lab_wire.sym} 660 -40 2 0 {name=p22 sig_type=std_logic lab=f2}
C {ipin.sym} 640 -20 0 0 {name=p23 lab=f3}
C {lab_wire.sym} 660 -20 2 0 {name=p24 sig_type=std_logic lab=f3}
C {ipin.sym} 640 0 0 0 {name=p25 lab=f4}
C {lab_wire.sym} 660 0 2 0 {name=p26 sig_type=std_logic lab=f4}
C {ipin.sym} 640 20 0 0 {name=p27 lab=f5}
C {lab_wire.sym} 660 20 2 0 {name=p28 sig_type=std_logic lab=f5}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/3bit_to_8_outs.sym} 50 -20 0 0 {name=Column}
C {lab_wire.sym} -120 -90 0 0 {name=p29 sig_type=std_logic lab=c1}
C {lab_wire.sym} -120 -70 0 0 {name=p30 sig_type=std_logic lab=c2}
C {lab_wire.sym} -120 -110 0 0 {name=p31 sig_type=std_logic lab=c0}
C {lab_wire.sym} 220 -90 2 0 {name=p32 sig_type=std_logic lab=VP}
C {lab_wire.sym} 220 -110 2 0 {name=p33 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 80 -930 0 0 {name=x2}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 80 -840 0 0 {name=x3}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_3in.sym} 80 -690 0 0 {name=x4}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 80 -500 0 0 {name=x5}
C {lab_wire.sym} 250 -950 2 0 {name=p34 sig_type=std_logic lab=VP}
C {lab_wire.sym} 250 -930 2 0 {name=p35 sig_type=std_logic lab=gd}
C {lab_wire.sym} 250 -860 2 0 {name=p36 sig_type=std_logic lab=VP}
C {lab_wire.sym} 250 -840 2 0 {name=p37 sig_type=std_logic lab=gd}
C {lab_wire.sym} 250 -710 2 0 {name=p38 sig_type=std_logic lab=VP}
C {lab_wire.sym} 250 -690 2 0 {name=p39 sig_type=std_logic lab=gd}
C {lab_wire.sym} 250 -520 2 0 {name=p40 sig_type=std_logic lab=VP}
C {lab_wire.sym} 250 -500 2 0 {name=p41 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 450 -890 0 0 {name=x6}
C {lab_wire.sym} 620 -910 2 0 {name=p42 sig_type=std_logic lab=VP}
C {lab_wire.sym} 620 -890 2 0 {name=p43 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 300 -670 0 0 {name=x7}
C {lab_wire.sym} 300 -620 3 0 {name=p44 sig_type=std_logic lab=gd}
C {lab_wire.sym} 300 -720 1 0 {name=p45 sig_type=std_logic lab=VP}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 300 -480 0 0 {name=x8}
C {lab_wire.sym} 300 -430 3 0 {name=p47 sig_type=std_logic lab=gd}
C {lab_wire.sym} 300 -530 1 0 {name=p48 sig_type=std_logic lab=VP}
C {lab_wire.sym} -90 -950 0 0 {name=p49 sig_type=std_logic lab=f2}
C {lab_wire.sym} -90 -710 0 0 {name=p50 sig_type=std_logic lab=f3}
C {lab_wire.sym} -90 -690 0 0 {name=p51 sig_type=std_logic lab=f4}
C {lab_wire.sym} -90 -670 0 0 {name=p52 sig_type=std_logic lab=f5}
C {lab_wire.sym} -90 -860 0 0 {name=p62 sig_type=std_logic lab=f4}
C {lab_wire.sym} -90 -840 0 0 {name=p64 sig_type=std_logic lab=f5}
C {lab_wire.sym} -90 -930 0 0 {name=p65 sig_type=std_logic lab=f3}
C {lab_wire.sym} -90 -520 0 0 {name=p66 sig_type=std_logic lab=f4}
C {lab_wire.sym} -90 -500 0 0 {name=p67 sig_type=std_logic lab=f5}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 640 -790 0 0 {name=x9}
C {lab_wire.sym} 640 -740 3 0 {name=p68 sig_type=std_logic lab=gd}
C {lab_wire.sym} 640 -840 1 0 {name=p69 sig_type=std_logic lab=VP}
C {lab_wire.sym} 700 -870 2 0 {name=p70 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 700 -790 2 0 {name=p71 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 360 -670 2 0 {name=p72 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 360 -590 2 0 {name=p73 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 360 -480 2 0 {name=p74 sig_type=std_logic lab=after_001111}
C {lab_wire.sym} 360 -400 2 0 {name=p75 sig_type=std_logic lab=after_001111_n}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 640 -620 0 0 {name=x1}
C {lab_wire.sym} 640 -570 3 0 {name=p76 sig_type=std_logic lab=gd}
C {lab_wire.sym} 640 -670 1 0 {name=p77 sig_type=std_logic lab=VP}
C {lab_wire.sym} 700 -620 2 0 {name=p78 sig_type=std_logic lab=f1_n}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 640 -450 0 0 {name=x10}
C {lab_wire.sym} 640 -400 3 0 {name=p79 sig_type=std_logic lab=gd}
C {lab_wire.sym} 640 -500 1 0 {name=p80 sig_type=std_logic lab=VP}
C {lab_wire.sym} 700 -450 2 0 {name=p81 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 600 -620 0 0 {name=p82 sig_type=std_logic lab=f1}
C {lab_wire.sym} 600 -450 0 0 {name=p83 sig_type=std_logic lab=f5}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 -890 0 0 {name=x11}
C {lab_wire.sym} 1360 -910 2 0 {name=p84 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -890 2 0 {name=p85 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 -810 0 0 {name=x12}
C {lab_wire.sym} 1360 -830 2 0 {name=p86 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -810 2 0 {name=p87 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 -730 0 0 {name=x13}
C {lab_wire.sym} 1360 -750 2 0 {name=p88 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -730 2 0 {name=p89 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1020 -910 0 0 {name=p101 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 1020 -830 0 0 {name=p103 sig_type=std_logic lab=after_001111}
C {lab_wire.sym} 230 -70 2 0 {name=p105 sig_type=std_logic lab=000}
C {lab_wire.sym} 230 -50 2 0 {name=p106 sig_type=std_logic lab=001}
C {lab_wire.sym} 230 -10 2 0 {name=p107 sig_type=std_logic lab=011}
C {lab_wire.sym} 230 10 2 0 {name=p108 sig_type=std_logic lab=100}
C {lab_wire.sym} 230 30 2 0 {name=p109 sig_type=std_logic lab=101}
C {lab_wire.sym} 230 50 2 0 {name=p110 sig_type=std_logic lab=110}
C {lab_wire.sym} 230 70 2 0 {name=p111 sig_type=std_logic lab=111}
C {lab_wire.sym} 230 -30 2 0 {name=p112 sig_type=std_logic lab=010}
C {lab_wire.sym} 1020 -750 0 0 {name=p119 sig_type=std_logic lab=101}
C {lab_wire.sym} 1020 -810 0 0 {name=p120 sig_type=std_logic lab=110}
C {lab_wire.sym} 1020 -890 0 0 {name=p123 sig_type=std_logic lab=111}
C {lab_wire.sym} 1020 -490 0 0 {name=p124 sig_type=std_logic lab=101}
C {lab_wire.sym} 1020 -570 0 0 {name=p125 sig_type=std_logic lab=110}
C {lab_wire.sym} 1020 -730 0 0 {name=p126 sig_type=std_logic lab=f5}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1610 -850 0 0 {name=x14}
C {lab_wire.sym} 1780 -870 2 0 {name=p127 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1780 -850 2 0 {name=p128 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1810 -830 2 0 {name=p129 sig_type=std_logic lab=VCO_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1190 -550 0 0 {name=x15}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 -390 0 0 {name=x16}
C {lab_wire.sym} 1360 -570 2 0 {name=p130 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -550 2 0 {name=p131 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1360 -410 2 0 {name=p132 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -390 2 0 {name=p133 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1190 -470 0 0 {name=x17}
C {lab_wire.sym} 1360 -490 2 0 {name=p134 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -470 2 0 {name=p135 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1190 -310 0 0 {name=x18}
C {lab_wire.sym} 1360 -330 2 0 {name=p136 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -310 2 0 {name=p137 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1020 -410 0 0 {name=p140 sig_type=std_logic lab=100}
C {lab_wire.sym} 1020 -330 0 0 {name=p141 sig_type=std_logic lab=111}
C {lab_wire.sym} 1020 -550 0 0 {name=p142 sig_type=std_logic lab=after_001111_n}
C {lab_wire.sym} 1020 -530 0 0 {name=p145 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 1020 -470 0 0 {name=p146 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 1020 -450 0 0 {name=p147 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 1020 -390 0 0 {name=p90 sig_type=std_logic lab=f5}
C {lab_wire.sym} 1020 -310 0 0 {name=p91 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 1020 -290 0 0 {name=p94 sig_type=std_logic lab=after_000111_n}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_4in.sym} 1590 -500 0 0 {name=x19}
C {lab_wire.sym} 1760 -530 2 0 {name=p148 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1760 -510 2 0 {name=p149 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1790 -490 2 0 {name=p150 sig_type=std_logic lab=VCO2_5_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2080 50 0 0 {name=x20}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 1700 10 0 0 {name=x21}
C {lab_wire.sym} 1870 -10 2 0 {name=p151 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 10 2 0 {name=p152 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 1700 80 0 0 {name=x22}
C {lab_wire.sym} 1870 60 2 0 {name=p153 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 80 2 0 {name=p154 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 1700 150 0 0 {name=x23}
C {lab_wire.sym} 1870 130 2 0 {name=p155 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 150 2 0 {name=p156 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2250 30 2 0 {name=p157 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2250 50 2 0 {name=p158 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1190 -200 0 0 {name=x24}
C {lab_wire.sym} 1360 -220 2 0 {name=p159 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -200 2 0 {name=p160 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 -80 0 0 {name=x25}
C {lab_wire.sym} 1360 -100 2 0 {name=p161 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 -80 2 0 {name=p162 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1410 -180 0 0 {name=x26}
C {lab_wire.sym} 1410 -220 0 1 {name=p163 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1410 -140 2 0 {name=p164 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1410 -60 0 0 {name=x27}
C {lab_wire.sym} 1410 -100 0 1 {name=p165 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1410 -20 2 0 {name=p166 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 40 0 0 {name=x28}
C {lab_wire.sym} 1360 20 2 0 {name=p167 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 40 2 0 {name=p168 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1410 60 0 0 {name=x29}
C {lab_wire.sym} 1410 20 0 1 {name=p169 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1410 100 2 0 {name=p170 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 1190 160 0 0 {name=x30}
C {lab_wire.sym} 1360 140 2 0 {name=p171 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 160 2 0 {name=p172 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1410 180 0 0 {name=x31}
C {lab_wire.sym} 1410 140 0 1 {name=p173 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1410 220 2 0 {name=p174 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1190 280 0 0 {name=x32}
C {lab_wire.sym} 1360 260 2 0 {name=p175 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 280 2 0 {name=p176 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1410 300 0 0 {name=x33}
C {lab_wire.sym} 1410 260 0 1 {name=p177 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1410 340 2 0 {name=p178 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1680 390 0 0 {name=x34}
C {lab_wire.sym} 1850 370 2 0 {name=p179 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1850 390 2 0 {name=p180 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1900 410 0 0 {name=x35}
C {lab_wire.sym} 1900 370 0 1 {name=p181 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1900 450 2 0 {name=p182 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1680 510 0 0 {name=x36}
C {lab_wire.sym} 1850 490 2 0 {name=p183 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1850 510 2 0 {name=p184 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1900 530 0 0 {name=x37}
C {lab_wire.sym} 1900 490 0 1 {name=p185 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1900 570 2 0 {name=p186 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 2120 430 0 0 {name=x38}
C {lab_wire.sym} 2290 410 2 0 {name=p189 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2290 430 2 0 {name=p190 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 2340 450 0 0 {name=x40}
C {lab_wire.sym} 2340 410 0 1 {name=p191 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2340 490 2 0 {name=p192 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 1190 390 0 0 {name=x39}
C {lab_wire.sym} 1360 370 2 0 {name=p187 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1360 390 2 0 {name=p188 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1020 -220 0 0 {name=p193 sig_type=std_logic lab=100}
C {lab_wire.sym} 1020 -100 0 0 {name=p194 sig_type=std_logic lab=011}
C {lab_wire.sym} 1020 20 0 0 {name=p195 sig_type=std_logic lab=010}
C {lab_wire.sym} 1020 140 0 0 {name=p196 sig_type=std_logic lab=111}
C {lab_wire.sym} 1020 260 0 0 {name=p197 sig_type=std_logic lab=101}
C {lab_wire.sym} 1510 370 0 0 {name=p199 sig_type=std_logic lab=110}
C {lab_wire.sym} 1510 490 0 0 {name=p200 sig_type=std_logic lab=110}
C {lab_wire.sym} 1020 -200 0 0 {name=p198 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 1020 -180 0 0 {name=p201 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 1020 -80 0 0 {name=p202 sig_type=std_logic lab=after_001111}
C {lab_wire.sym} 1020 40 0 0 {name=p203 sig_type=std_logic lab=f5}
C {lab_wire.sym} 1020 160 0 0 {name=p204 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 1020 280 0 0 {name=p205 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 1020 300 0 0 {name=p206 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 1510 390 0 0 {name=p207 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 1510 510 0 0 {name=p208 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 1510 530 0 0 {name=p209 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 1020 370 0 0 {name=p210 sig_type=std_logic lab=f0}
C {lab_wire.sym} 1020 390 0 0 {name=p211 sig_type=std_logic lab=f1}
C {lab_wire.sym} 2250 70 2 0 {name=p212 sig_type=std_logic lab=VCO2_11_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3270 970 0 0 {name=x41}
C {lab_wire.sym} 3440 950 2 0 {name=p213 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3440 970 2 0 {name=p214 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3440 830 2 0 {name=p217 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3440 850 2 0 {name=p218 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3490 870 0 0 {name=x44}
C {lab_wire.sym} 3490 830 0 1 {name=p219 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3490 910 2 0 {name=p220 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 3270 850 0 0 {name=x43}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 -1000 0 0 {name=x45}
C {lab_wire.sym} 2970 -1020 2 0 {name=p221 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -1000 2 0 {name=p222 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -980 0 0 {name=x46}
C {lab_wire.sym} 3020 -1020 0 1 {name=p223 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -940 2 0 {name=p224 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 -880 0 0 {name=x47}
C {lab_wire.sym} 2970 -900 2 0 {name=p225 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -880 2 0 {name=p226 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -860 0 0 {name=x48}
C {lab_wire.sym} 3020 -900 0 1 {name=p227 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -820 2 0 {name=p228 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2970 -780 2 0 {name=p229 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -760 2 0 {name=p230 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -740 0 0 {name=x49}
C {lab_wire.sym} 3020 -780 0 1 {name=p231 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -700 2 0 {name=p232 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 2800 -760 0 0 {name=x50}
C {lab_wire.sym} 2970 -660 2 0 {name=p233 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -640 2 0 {name=p234 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -620 0 0 {name=x51}
C {lab_wire.sym} 3020 -660 0 1 {name=p235 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -580 2 0 {name=p236 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 2800 -640 0 0 {name=x52}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 -520 0 0 {name=x53}
C {lab_wire.sym} 2970 -540 2 0 {name=p237 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -520 2 0 {name=p238 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -500 0 0 {name=x54}
C {lab_wire.sym} 3020 -540 0 1 {name=p239 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -460 2 0 {name=p240 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 -400 0 0 {name=x55}
C {lab_wire.sym} 2970 -420 2 0 {name=p241 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -400 2 0 {name=p242 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -380 0 0 {name=x56}
C {lab_wire.sym} 3020 -420 0 1 {name=p243 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -340 2 0 {name=p244 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3760 -710 0 0 {name=x57}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3380 -750 0 0 {name=x58}
C {lab_wire.sym} 3550 -770 2 0 {name=p245 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3550 -750 2 0 {name=p246 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3380 -680 0 0 {name=x59}
C {lab_wire.sym} 3550 -700 2 0 {name=p247 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3550 -680 2 0 {name=p248 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3380 -610 0 0 {name=x60}
C {lab_wire.sym} 3550 -630 2 0 {name=p249 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3550 -610 2 0 {name=p250 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3930 -730 2 0 {name=p251 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3930 -710 2 0 {name=p252 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2630 -1020 0 0 {name=p253 sig_type=std_logic lab=011}
C {lab_wire.sym} 2630 -900 0 0 {name=p254 sig_type=std_logic lab=010}
C {lab_wire.sym} 2630 -780 0 0 {name=p255 sig_type=std_logic lab=001}
C {lab_wire.sym} 2630 -660 0 0 {name=p256 sig_type=std_logic lab=101}
C {lab_wire.sym} 2630 -420 0 0 {name=p257 sig_type=std_logic lab=110}
C {lab_wire.sym} 2630 -540 0 0 {name=p258 sig_type=std_logic lab=100}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 2800 -270 0 0 {name=x61}
C {lab_wire.sym} 2970 -290 2 0 {name=p259 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -270 2 0 {name=p260 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -250 0 0 {name=x62}
C {lab_wire.sym} 3020 -290 0 1 {name=p261 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -210 2 0 {name=p262 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2630 -1000 0 0 {name=p263 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 2630 -980 0 0 {name=p264 sig_type=std_logic lab=after_001111_n}
C {lab_wire.sym} 2630 -880 0 0 {name=p265 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 2630 -860 0 0 {name=p266 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 2630 -760 0 0 {name=p267 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 2630 -640 0 0 {name=p268 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2630 -520 0 0 {name=p269 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 2630 -500 0 0 {name=p270 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 2630 -400 0 0 {name=p271 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2630 -290 0 0 {name=p272 sig_type=std_logic lab=f0}
C {lab_wire.sym} 2630 -270 0 0 {name=p273 sig_type=std_logic lab=f1}
C {lab_wire.sym} 3930 -690 2 0 {name=p274 sig_type=std_logic lab=VCO3_5_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3290 370 0 0 {name=x63}
C {lab_wire.sym} 3460 350 2 0 {name=p275 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3460 370 2 0 {name=p276 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3510 390 0 0 {name=x64}
C {lab_wire.sym} 3510 350 0 1 {name=p277 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3510 430 2 0 {name=p278 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3290 490 0 0 {name=x65}
C {lab_wire.sym} 3460 470 2 0 {name=p279 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3460 490 2 0 {name=p280 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3510 510 0 0 {name=x66}
C {lab_wire.sym} 3510 470 0 1 {name=p281 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3510 550 2 0 {name=p282 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3730 410 0 0 {name=x67}
C {lab_wire.sym} 3900 390 2 0 {name=p283 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3900 410 2 0 {name=p284 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 2800 370 0 0 {name=x69}
C {lab_wire.sym} 2970 350 2 0 {name=p287 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 370 2 0 {name=p288 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 -110 0 0 {name=x70}
C {lab_wire.sym} 2970 -130 2 0 {name=p289 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 -110 2 0 {name=p290 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 -90 0 0 {name=x71}
C {lab_wire.sym} 3020 -130 0 1 {name=p291 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 -50 2 0 {name=p292 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2970 -10 2 0 {name=p293 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 10 2 0 {name=p294 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 30 0 0 {name=x72}
C {lab_wire.sym} 3020 -10 0 1 {name=p295 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 70 2 0 {name=p296 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 2800 10 0 0 {name=x73}
C {lab_wire.sym} 2970 110 2 0 {name=p297 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 130 2 0 {name=p298 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 150 0 0 {name=x74}
C {lab_wire.sym} 3020 110 0 1 {name=p299 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 190 2 0 {name=p300 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 2800 130 0 0 {name=x75}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 2800 250 0 0 {name=x76}
C {lab_wire.sym} 2970 230 2 0 {name=p301 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2970 250 2 0 {name=p302 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3020 270 0 0 {name=x77}
C {lab_wire.sym} 3020 230 0 1 {name=p303 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3020 310 2 0 {name=p304 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3760 110 0 0 {name=x68}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3380 70 0 0 {name=x78}
C {lab_wire.sym} 3550 50 2 0 {name=p285 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3550 70 2 0 {name=p286 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3380 140 0 0 {name=x79}
C {lab_wire.sym} 3550 120 2 0 {name=p305 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3550 140 2 0 {name=p306 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3930 90 2 0 {name=p309 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3930 110 2 0 {name=p310 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2630 -130 0 0 {name=p307 sig_type=std_logic lab=001}
C {lab_wire.sym} 2630 -10 0 0 {name=p308 sig_type=std_logic lab=000}
C {lab_wire.sym} 2630 110 0 0 {name=p311 sig_type=std_logic lab=100}
C {lab_wire.sym} 2630 230 0 0 {name=p312 sig_type=std_logic lab=010}
C {lab_wire.sym} 3120 350 0 0 {name=p313 sig_type=std_logic lab=011}
C {lab_wire.sym} 3120 470 0 0 {name=p314 sig_type=std_logic lab=011}
C {lab_wire.sym} 2630 -110 0 0 {name=p315 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 2630 -90 0 0 {name=p316 sig_type=std_logic lab=f5_n}
C {lab_wire.sym} 2630 10 0 0 {name=p317 sig_type=std_logic lab=after_001111}
C {lab_wire.sym} 2630 130 0 0 {name=p318 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 2630 250 0 0 {name=p319 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 2630 270 0 0 {name=p320 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 2630 350 0 0 {name=p321 sig_type=std_logic lab=f0}
C {lab_wire.sym} 2630 370 0 0 {name=p322 sig_type=std_logic lab=f1}
C {lab_wire.sym} 3120 370 0 0 {name=p323 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 3120 490 0 0 {name=p324 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 3120 510 0 0 {name=p325 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 3930 130 2 0 {name=p326 sig_type=std_logic lab=VCO3_11_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 710 0 0 {name=x80}
C {lab_wire.sym} 1870 690 2 0 {name=p327 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 710 2 0 {name=p328 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 730 0 0 {name=x81}
C {lab_wire.sym} 1920 690 0 1 {name=p329 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 770 2 0 {name=p330 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 840 0 0 {name=x82}
C {lab_wire.sym} 1870 820 2 0 {name=p331 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 840 2 0 {name=p332 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 860 0 0 {name=x83}
C {lab_wire.sym} 1920 820 0 1 {name=p333 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 900 2 0 {name=p334 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 970 0 0 {name=x84}
C {lab_wire.sym} 1870 950 2 0 {name=p335 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 970 2 0 {name=p336 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 990 0 0 {name=x85}
C {lab_wire.sym} 1920 950 0 1 {name=p337 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 1030 2 0 {name=p338 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 1100 0 0 {name=x86}
C {lab_wire.sym} 1870 1080 2 0 {name=p339 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 1100 2 0 {name=p340 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 1120 0 0 {name=x87}
C {lab_wire.sym} 1920 1080 0 1 {name=p341 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 1160 2 0 {name=p342 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 1230 0 0 {name=x88}
C {lab_wire.sym} 1870 1210 2 0 {name=p343 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 1230 2 0 {name=p344 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 1250 0 0 {name=x89}
C {lab_wire.sym} 1920 1210 0 1 {name=p345 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 1290 2 0 {name=p346 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 1700 1360 0 0 {name=x90}
C {lab_wire.sym} 1870 1340 2 0 {name=p347 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1870 1360 2 0 {name=p348 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1920 1380 0 0 {name=x91}
C {lab_wire.sym} 1920 1340 0 1 {name=p349 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1920 1420 2 0 {name=p350 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 2280 890 0 0 {name=x92}
C {lab_wire.sym} 2450 870 2 0 {name=p351 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2450 890 2 0 {name=p352 sig_type=std_logic lab=gd}
C {lab_wire.sym} 2450 950 2 0 {name=p353 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2450 970 2 0 {name=p354 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 2630 930 0 0 {name=x93}
C {lab_wire.sym} 2800 910 2 0 {name=p355 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2800 930 2 0 {name=p356 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 2280 970 0 0 {name=x94}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 2190 1200 0 0 {name=x97}
C {lab_wire.sym} 2360 1180 2 0 {name=p359 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2360 1200 2 0 {name=p360 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 2410 1220 0 0 {name=x98}
C {lab_wire.sym} 2410 1180 0 1 {name=p361 sig_type=std_logic lab=VP}
C {lab_wire.sym} 2410 1260 2 0 {name=p362 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1530 690 0 0 {name=p357 sig_type=std_logic lab=000}
C {lab_wire.sym} 1530 820 0 0 {name=p358 sig_type=std_logic lab=010}
C {lab_wire.sym} 1530 950 0 0 {name=p363 sig_type=std_logic lab=011}
C {lab_wire.sym} 1530 1080 0 0 {name=p364 sig_type=std_logic lab=001}
C {lab_wire.sym} 1530 1210 0 0 {name=p365 sig_type=std_logic lab=001}
C {lab_wire.sym} 1530 1340 0 0 {name=p366 sig_type=std_logic lab=000}
C {lab_wire.sym} 1530 1380 0 0 {name=p367 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 1530 1360 0 0 {name=p368 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 2050 1380 2 0 {name=p369 sig_type=std_logic lab=VCO4_11_sel}
C {lab_wire.sym} 2840 950 2 0 {name=p370 sig_type=std_logic lab=VCO4_5_sel}
C {lab_wire.sym} 1530 730 0 0 {name=p371 sig_type=std_logic lab=after_001111_n}
C {lab_wire.sym} 1530 710 0 0 {name=p372 sig_type=std_logic lab=after_000111}
C {lab_wire.sym} 1530 840 0 0 {name=p373 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 1530 860 0 0 {name=p374 sig_type=std_logic lab=f1}
C {lab_wire.sym} 1530 1230 0 0 {name=p375 sig_type=std_logic lab=after_000011}
C {lab_wire.sym} 1530 1250 0 0 {name=p376 sig_type=std_logic lab=after_000111_n}
C {lab_wire.sym} 1530 1120 0 0 {name=p377 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 1530 990 0 0 {name=p378 sig_type=std_logic lab=after_000011_n}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 1150 1080 0 0 {name=x96}
C {lab_wire.sym} 1320 1060 2 0 {name=p379 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1320 1080 2 0 {name=p380 sig_type=std_logic lab=gd}
C {lab_wire.sym} 1320 930 2 0 {name=p381 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1320 950 2 0 {name=p382 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 1370 970 0 0 {name=x99}
C {lab_wire.sym} 1370 930 0 1 {name=p383 sig_type=std_logic lab=VP}
C {lab_wire.sym} 1370 1010 2 0 {name=p384 sig_type=std_logic lab=gd}
C {lab_wire.sym} 980 930 0 0 {name=p385 sig_type=std_logic lab=f0}
C {lab_wire.sym} 980 1060 0 0 {name=p386 sig_type=std_logic lab=f0}
C {lab_wire.sym} 980 950 0 0 {name=p387 sig_type=std_logic lab=f1}
C {lab_wire.sym} 980 1080 0 0 {name=p388 sig_type=std_logic lab=f1}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_3in.sym} 3820 740 0 0 {name=x95}
C {lab_wire.sym} 3990 720 2 0 {name=p390 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3990 740 2 0 {name=p391 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 4040 760 0 0 {name=x101}
C {lab_wire.sym} 4040 720 0 1 {name=p392 sig_type=std_logic lab=VP}
C {lab_wire.sym} 4040 800 2 0 {name=p393 sig_type=std_logic lab=gd}
C {lab_wire.sym} 3440 700 2 0 {name=p396 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3440 720 2 0 {name=p397 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/inverter.sym} 3490 740 0 0 {name=x102}
C {lab_wire.sym} 3490 700 0 1 {name=p398 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3490 780 2 0 {name=p399 sig_type=std_logic lab=gd}
C {lab_wire.sym} 4330 930 2 0 {name=p389 sig_type=std_logic lab=VCO5_11_sel}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NOR_2in.sym} 3770 870 0 0 {name=x104}
C {lab_wire.sym} 3940 850 2 0 {name=p394 sig_type=std_logic lab=VP}
C {lab_wire.sym} 3940 870 2 0 {name=p395 sig_type=std_logic lab=gd}
C {lab_wire.sym} 4300 890 2 0 {name=p400 sig_type=std_logic lab=VP}
C {lab_wire.sym} 4300 910 2 0 {name=p401 sig_type=std_logic lab=gd}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/NAND_2in.sym} 4130 910 0 0 {name=x106}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 1150 950 0 0 {name=x42}
C {/foss/designs/CHIP-PLL/schematics/divider/schematics/XNOR.sym} 3270 720 0 0 {name=x100}
C {lab_wire.sym} 3650 720 0 0 {name=p215 sig_type=std_logic lab=001}
C {lab_wire.sym} 3100 830 0 0 {name=p216 sig_type=std_logic lab=000}
C {lab_wire.sym} 3650 760 0 0 {name=p402 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 3100 700 0 0 {name=p403 sig_type=std_logic lab=f0}
C {lab_wire.sym} 3100 720 0 0 {name=p404 sig_type=std_logic lab=f1}
C {lab_wire.sym} 3100 850 0 0 {name=p405 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 3100 990 0 0 {name=p406 sig_type=std_logic lab=f1_n}
C {lab_wire.sym} 3100 970 0 0 {name=p407 sig_type=std_logic lab=after_000011_n}
C {lab_wire.sym} 3100 950 0 0 {name=p408 sig_type=std_logic lab=010}
