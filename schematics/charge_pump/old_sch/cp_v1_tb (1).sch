v {xschem version=3.4.8RC file_version=1.3}
G {}
K {type=subcircuit
format="@name @pinlist @symname"
template="name=X1"}
V {}
S {}
F {}
E {}
L 4 80 -240 80 -140 {}
L 4 80 -140 220 -140 {}
L 4 220 -240 220 -140 {}
L 4 80 -240 220 -240 {}
L 4 120 -220 140 -220 {}
L 4 120 -220 120 -180 {}
L 4 120 -180 140 -180 {}
L 4 160 -220 160 -180 {}
L 4 160 -220 180 -220 {}
L 4 180 -220 180 -200 {}
L 4 160 -200 180 -200 {}
B 5 77.5 -182.5 82.5 -177.5 {name=dn
dir=in}
B 5 77.5 -222.5 82.5 -217.5 {name=upb
dir=in}
B 5 157.5 -242.5 162.5 -237.5 {name=vp
dir=inout}
B 5 217.5 -202.5 222.5 -197.5 {name=vout
dir=out}
