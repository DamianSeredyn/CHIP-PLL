** sch_path: schematics/misc/RC_filter.sch
**.subckt RC_filter in gd
*.ipin in
*.ipin gd
R1 in net1 100k m=1
C1 net1 gd 10p m=1
C2 in gd 50p m=1
**.ends
.end
