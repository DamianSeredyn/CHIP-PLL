v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -410 50 -390 50 {lab=VP}
N -410 70 -390 70 {lab=GND}
N -410 100 -390 100 {lab=c0}
N 120 -50 130 -50 {lab=VP}
N 120 -30 130 -30 {lab=GND}
N -200 -30 -180 -30 {lab=c0}
N -200 -50 -180 -50 {lab=d0}
N 120 20 130 20 {lab=VP}
N 120 40 130 40 {lab=GND}
N -200 40 -180 40 {lab=c1}
N -200 20 -180 20 {lab=d1}
N 120 90 130 90 {lab=VP}
N 120 110 130 110 {lab=GND}
N -200 110 -180 110 {lab=c2}
N -200 90 -180 90 {lab=d2}
N 120 160 130 160 {lab=VP}
N 120 180 130 180 {lab=GND}
N -200 180 -180 180 {lab=c3}
N -200 160 -180 160 {lab=d3}
N 120 230 130 230 {lab=VP}
N 120 250 130 250 {lab=GND}
N -200 250 -180 250 {lab=c4}
N -200 230 -180 230 {lab=d4}
N 120 300 130 300 {lab=VP}
N 120 320 130 320 {lab=GND}
N -200 320 -180 320 {lab=c5}
N -200 300 -180 300 {lab=d5}
N 120 370 130 370 {lab=VP}
N 120 390 130 390 {lab=GND}
N -200 390 -180 390 {lab=c6}
N -200 370 -180 370 {lab=d6}
N 120 440 130 440 {lab=VP}
N 120 460 130 460 {lab=GND}
N -200 460 -180 460 {lab=c7}
N -200 440 -180 440 {lab=d7}
N 120 510 130 510 {lab=VP}
N 120 530 130 530 {lab=GND}
N -200 530 -180 530 {lab=c8}
N -200 510 -180 510 {lab=d8}
N 120 580 130 580 {lab=VP}
N 120 600 130 600 {lab=GND}
N -200 600 -180 600 {lab=c9}
N -200 580 -180 580 {lab=d9}
N 120 650 130 650 {lab=VP}
N 120 670 130 670 {lab=GND}
N -200 670 -180 670 {lab=c10}
N -200 650 -180 650 {lab=d10}
N 120 720 130 720 {lab=VP}
N 120 740 130 740 {lab=GND}
N -200 740 -180 740 {lab=c11}
N -200 720 -180 720 {lab=d11}
N 120 790 130 790 {lab=VP}
N 120 810 130 810 {lab=GND}
N -200 810 -180 810 {lab=c12}
N -200 790 -180 790 {lab=d12}
N 120 -10 150 -10 {lab=y0}
N 120 60 150 60 {lab=y1}
N 120 130 150 130 {lab=y2}
N 120 200 150 200 {lab=y3}
N 120 270 150 270 {lab=y4}
N 120 340 150 340 {lab=y5}
N 120 410 150 410 {lab=y6}
N 120 480 150 480 {lab=y7}
N 120 550 150 550 {lab=y8}
N 120 620 150 620 {lab=y9}
N 120 690 150 690 {lab=y10}
N 120 760 150 760 {lab=y11}
N 120 830 150 830 {lab=y12}
N 280 -10 310 -10 {lab=y0}
N 280 10 310 10 {lab=y1}
N 280 30 310 30 {lab=y2}
N 610 -10 620 -10 {lab=VP}
N 610 10 620 10 {lab=GND}
N 280 90 310 90 {lab=y3}
N 280 110 310 110 {lab=y4}
N 280 130 310 130 {lab=y5}
N 610 90 620 90 {lab=VP}
N 610 110 620 110 {lab=GND}
N 280 190 310 190 {lab=y6}
N 280 210 310 210 {lab=y7}
N 280 230 310 230 {lab=y8}
N 610 190 620 190 {lab=VP}
N 610 210 620 210 {lab=GND}
N 280 290 310 290 {lab=y9}
N 280 310 310 310 {lab=y10}
N 280 330 310 330 {lab=y11}
N 610 290 620 290 {lab=VP}
N 610 310 620 310 {lab=GND}
N 610 30 740 30 {lab=#net1}
N 1040 310 1050 310 {lab=VP}
N 1040 330 1050 330 {lab=GND}
N 610 130 680 130 {lab=#net2}
N 680 50 680 130 {lab=#net2}
N 680 50 740 50 {lab=#net2}
N 610 330 740 330 {lab=#net3}
N 610 230 690 230 {lab=#net4}
N 690 230 690 310 {lab=#net4}
N 690 310 740 310 {lab=#net4}
N 1540 200 1560 200 {lab=out}
N -410 120 -390 120 {lab=c1}
N -410 10 -390 10 {lab=out}
N -410 140 -390 140 {lab=c2}
N -410 160 -390 160 {lab=c3}
N -410 180 -390 180 {lab=c4}
N -410 200 -390 200 {lab=c5}
N -410 220 -390 220 {lab=c6}
N -410 240 -390 240 {lab=c7}
N -410 260 -390 260 {lab=c8}
N -410 280 -390 280 {lab=c9}
N -410 300 -390 300 {lab=c10}
N -410 320 -390 320 {lab=c11}
N -410 340 -390 340 {lab=c12}
N -410 410 -390 410 {lab=d0}
N -410 430 -390 430 {lab=d1}
N -410 450 -390 450 {lab=d2}
N -410 470 -390 470 {lab=d3}
N -410 490 -390 490 {lab=d4}
N -410 510 -390 510 {lab=d5}
N -410 530 -390 530 {lab=d6}
N -410 550 -390 550 {lab=d7}
N -410 570 -390 570 {lab=d8}
N -410 590 -390 590 {lab=d9}
N -410 610 -390 610 {lab=d10}
N -410 630 -390 630 {lab=d11}
N -410 650 -390 650 {lab=d12}
N 1100 180 1110 180 {lab=y12}
N 1030 30 1040 30 {lab=VP}
N 1030 50 1040 50 {lab=GND}
N 1490 160 1490 170 {lab=VP}
N 1490 230 1490 240 {lab=GND}
N 1410 160 1420 160 {lab=VP}
N 1410 180 1420 180 {lab=GND}
N 1030 70 1070 70 {lab=#net5}
N 1070 70 1070 160 {lab=#net5}
N 1070 160 1110 160 {lab=#net5}
N 1040 350 1100 350 {lab=#net6}
N 1100 200 1100 350 {lab=#net6}
N 1100 200 1110 200 {lab=#net6}
N 1410 200 1470 200 {lab=#net7}
C {iopin.sym} -410 70 2 0 {name=p2 lab=GND}
C {ipin.sym} -410 100 0 0 {name=p3 lab=c0}
C {iopin.sym} -410 50 2 0 {name=p5 lab=VP}
C {lab_pin.sym} -390 100 2 0 {name=p9 sig_type=std_logic lab=c0}
C {lab_pin.sym} -390 70 2 0 {name=p10 sig_type=std_logic lab=GND}
C {lab_pin.sym} -390 50 2 0 {name=p11 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 -50 2 0 {name=p1 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 -30 2 0 {name=p4 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 -50 0 0 {name=p7 sig_type=std_logic lab=d0}
C {lab_pin.sym} -200 -30 0 0 {name=p12 sig_type=std_logic lab=c0}
C {lab_pin.sym} 130 20 2 0 {name=p13 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 40 2 0 {name=p14 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 20 0 0 {name=p15 sig_type=std_logic lab=d1}
C {lab_pin.sym} -200 40 0 0 {name=p16 sig_type=std_logic lab=c1}
C {lab_pin.sym} 130 90 2 0 {name=p17 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 110 2 0 {name=p18 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 90 0 0 {name=p19 sig_type=std_logic lab=d2}
C {lab_pin.sym} -200 110 0 0 {name=p20 sig_type=std_logic lab=c2}
C {lab_pin.sym} 130 160 2 0 {name=p21 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 180 2 0 {name=p22 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 160 0 0 {name=p23 sig_type=std_logic lab=d3}
C {lab_pin.sym} -200 180 0 0 {name=p24 sig_type=std_logic lab=c3}
C {lab_pin.sym} 130 230 2 0 {name=p25 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 250 2 0 {name=p26 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 230 0 0 {name=p27 sig_type=std_logic lab=d4}
C {lab_pin.sym} -200 250 0 0 {name=p28 sig_type=std_logic lab=c4}
C {lab_pin.sym} 130 300 2 0 {name=p29 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 320 2 0 {name=p30 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 300 0 0 {name=p31 sig_type=std_logic lab=d5
}
C {lab_pin.sym} -200 320 0 0 {name=p32 sig_type=std_logic lab=c5}
C {lab_pin.sym} 130 370 2 0 {name=p33 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 390 2 0 {name=p34 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 370 0 0 {name=p35 sig_type=std_logic lab=d6}
C {lab_pin.sym} -200 390 0 0 {name=p36 sig_type=std_logic lab=c6}
C {lab_pin.sym} 130 440 2 0 {name=p37 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 460 2 0 {name=p38 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 440 0 0 {name=p39 sig_type=std_logic lab=d7}
C {lab_pin.sym} -200 460 0 0 {name=p40 sig_type=std_logic lab=c7}
C {lab_pin.sym} 130 510 2 0 {name=p41 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 530 2 0 {name=p42 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 510 0 0 {name=p43 sig_type=std_logic lab=d8}
C {lab_pin.sym} -200 530 0 0 {name=p44 sig_type=std_logic lab=c8}
C {lab_pin.sym} 130 580 2 0 {name=p45 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 600 2 0 {name=p46 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 580 0 0 {name=p47 sig_type=std_logic lab=d9}
C {lab_pin.sym} -200 600 0 0 {name=p48 sig_type=std_logic lab=c9}
C {lab_pin.sym} 130 650 2 0 {name=p49 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 670 2 0 {name=p50 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 650 0 0 {name=p51 sig_type=std_logic lab=d10}
C {lab_pin.sym} -200 670 0 0 {name=p52 sig_type=std_logic lab=c10}
C {lab_pin.sym} 130 720 2 0 {name=p53 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 740 2 0 {name=p54 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 720 0 0 {name=p55 sig_type=std_logic lab=d11}
C {lab_pin.sym} -200 740 0 0 {name=p56 sig_type=std_logic lab=c11}
C {lab_pin.sym} 130 790 2 0 {name=p57 sig_type=std_logic lab=VP}
C {lab_pin.sym} 130 810 2 0 {name=p58 sig_type=std_logic lab=GND}
C {lab_pin.sym} -200 790 0 0 {name=p59 sig_type=std_logic lab=d12}
C {lab_pin.sym} -200 810 0 0 {name=p60 sig_type=std_logic lab=c12}
C {lab_pin.sym} 150 -10 2 0 {name=p61 sig_type=std_logic lab=y0}
C {lab_pin.sym} 150 60 2 0 {name=p62 sig_type=std_logic lab=y1}
C {lab_pin.sym} 150 130 2 0 {name=p63 sig_type=std_logic lab=y2}
C {lab_pin.sym} 150 200 2 0 {name=p64 sig_type=std_logic lab=y3}
C {lab_pin.sym} 150 270 2 0 {name=p65 sig_type=std_logic lab=y4}
C {lab_pin.sym} 150 340 2 0 {name=p66 sig_type=std_logic lab=y5}
C {lab_pin.sym} 150 410 2 0 {name=p67 sig_type=std_logic lab=y6}
C {lab_pin.sym} 150 480 2 0 {name=p68 sig_type=std_logic lab=y7}
C {lab_pin.sym} 150 550 2 0 {name=p69 sig_type=std_logic lab=y8}
C {lab_pin.sym} 150 620 2 0 {name=p70 sig_type=std_logic lab=y9}
C {lab_pin.sym} 150 690 2 0 {name=p71 sig_type=std_logic lab=y10}
C {lab_pin.sym} 150 760 2 0 {name=p72 sig_type=std_logic lab=y11}
C {lab_pin.sym} 150 830 2 0 {name=p73 sig_type=std_logic lab=y12}
C {lab_pin.sym} 620 -10 2 0 {name=p74 sig_type=std_logic lab=VP}
C {lab_pin.sym} 620 10 2 0 {name=p75 sig_type=std_logic lab=GND}
C {lab_pin.sym} 280 -10 0 0 {name=p76 sig_type=std_logic lab=y0}
C {lab_pin.sym} 280 10 0 0 {name=p77 sig_type=std_logic lab=y1}
C {lab_pin.sym} 280 30 0 0 {name=p78 sig_type=std_logic lab=y2}
C {lab_pin.sym} 620 90 2 0 {name=p79 sig_type=std_logic lab=VP}
C {lab_pin.sym} 620 110 2 0 {name=p80 sig_type=std_logic lab=GND}
C {lab_pin.sym} 280 90 0 0 {name=p81 sig_type=std_logic lab=y3}
C {lab_pin.sym} 280 110 0 0 {name=p82 sig_type=std_logic lab=y4}
C {lab_pin.sym} 280 130 0 0 {name=p83 sig_type=std_logic lab=y5}
C {lab_pin.sym} 620 190 2 0 {name=p84 sig_type=std_logic lab=VP}
C {lab_pin.sym} 620 210 2 0 {name=p85 sig_type=std_logic lab=GND}
C {lab_pin.sym} 280 190 0 0 {name=p86 sig_type=std_logic lab=y6}
C {lab_pin.sym} 280 210 0 0 {name=p87 sig_type=std_logic lab=y7}
C {lab_pin.sym} 280 230 0 0 {name=p88 sig_type=std_logic lab=y8}
C {lab_pin.sym} 620 290 2 0 {name=p89 sig_type=std_logic lab=VP}
C {lab_pin.sym} 620 310 2 0 {name=p90 sig_type=std_logic lab=GND}
C {lab_pin.sym} 280 290 0 0 {name=p91 sig_type=std_logic lab=y9}
C {lab_pin.sym} 280 310 0 0 {name=p92 sig_type=std_logic lab=y10}
C {lab_pin.sym} 280 330 0 0 {name=p93 sig_type=std_logic lab=y11}
C {lab_pin.sym} 1100 180 0 0 {name=p96 sig_type=std_logic lab=y12}
C {lab_pin.sym} 1050 310 2 0 {name=p97 sig_type=std_logic lab=VP}
C {lab_pin.sym} 1050 330 2 0 {name=p98 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1560 200 2 0 {name=p99 sig_type=std_logic lab=out}
C {ipin.sym} -410 120 0 0 {name=p100 lab=c1}
C {opin.sym} -390 10 0 0 {name=p102 lab=out}
C {lab_pin.sym} -410 10 0 0 {name=p103 sig_type=std_logic lab=out}
C {ipin.sym} -410 140 0 0 {name=p104 lab=c2}
C {ipin.sym} -410 160 0 0 {name=p106 lab=c3}
C {ipin.sym} -410 180 0 0 {name=p108 lab=c4}
C {ipin.sym} -410 200 0 0 {name=p110 lab=c5}
C {ipin.sym} -410 220 0 0 {name=p112 lab=c6}
C {ipin.sym} -410 240 0 0 {name=p114 lab=c7}
C {ipin.sym} -410 260 0 0 {name=p116 lab=c8}
C {ipin.sym} -410 280 0 0 {name=p118 lab=c9}
C {ipin.sym} -410 300 0 0 {name=p120 lab=c10}
C {ipin.sym} -410 320 0 0 {name=p122 lab=c11}
C {ipin.sym} -410 340 0 0 {name=p124 lab=c12}
C {lab_pin.sym} -390 120 2 0 {name=p101 sig_type=std_logic lab=c1}
C {lab_pin.sym} -390 140 2 0 {name=p105 sig_type=std_logic lab=c2}
C {lab_pin.sym} -390 160 2 0 {name=p107 sig_type=std_logic lab=c3}
C {lab_pin.sym} -390 180 2 0 {name=p109 sig_type=std_logic lab=c4}
C {lab_pin.sym} -390 200 2 0 {name=p111 sig_type=std_logic lab=c5}
C {lab_pin.sym} -390 220 2 0 {name=p113 sig_type=std_logic lab=c6}
C {lab_pin.sym} -390 240 2 0 {name=p115 sig_type=std_logic lab=c7}
C {lab_pin.sym} -390 260 2 0 {name=p117 sig_type=std_logic lab=c8}
C {lab_pin.sym} -390 280 2 0 {name=p119 sig_type=std_logic lab=c9}
C {lab_pin.sym} -390 300 2 0 {name=p121 sig_type=std_logic lab=c10}
C {lab_pin.sym} -390 320 2 0 {name=p123 sig_type=std_logic lab=c11}
C {lab_pin.sym} -390 340 2 0 {name=p125 sig_type=std_logic lab=c12}
C {ipin.sym} -410 410 0 0 {name=p6 lab=d0}
C {lab_pin.sym} -390 410 2 0 {name=p8 sig_type=std_logic lab=d0}
C {ipin.sym} -410 430 0 0 {name=p126 lab=d1}
C {ipin.sym} -410 470 0 0 {name=p127 lab=d3}
C {ipin.sym} -410 490 0 0 {name=p128 lab=d4}
C {ipin.sym} -410 510 0 0 {name=p129 lab=d5}
C {ipin.sym} -410 530 0 0 {name=p130 lab=d6}
C {ipin.sym} -410 550 0 0 {name=p131 lab=d7}
C {ipin.sym} -410 570 0 0 {name=p132 lab=d8}
C {ipin.sym} -410 590 0 0 {name=p133 lab=d9}
C {ipin.sym} -410 610 0 0 {name=p134 lab=d10}
C {ipin.sym} -410 630 0 0 {name=p135 lab=d11}
C {ipin.sym} -410 650 0 0 {name=p136 lab=d12}
C {ipin.sym} -410 450 0 0 {name=p137 lab=d2}
C {lab_pin.sym} -390 430 2 0 {name=p138 sig_type=std_logic lab=d1}
C {lab_pin.sym} -390 450 2 0 {name=p139 sig_type=std_logic lab=d2}
C {lab_pin.sym} -390 470 2 0 {name=p140 sig_type=std_logic lab=d3}
C {lab_pin.sym} -390 490 2 0 {name=p141 sig_type=std_logic lab=d4}
C {lab_pin.sym} -390 510 2 0 {name=p142 sig_type=std_logic lab=d5}
C {lab_pin.sym} -390 530 2 0 {name=p143 sig_type=std_logic lab=d6}
C {lab_pin.sym} -390 550 2 0 {name=p144 sig_type=std_logic lab=d7}
C {lab_pin.sym} -390 570 2 0 {name=p145 sig_type=std_logic lab=d8}
C {lab_pin.sym} -390 590 2 0 {name=p146 sig_type=std_logic lab=d9}
C {lab_pin.sym} -390 610 2 0 {name=p147 sig_type=std_logic lab=d10}
C {lab_pin.sym} -390 630 2 0 {name=p148 sig_type=std_logic lab=d11}
C {lab_pin.sym} -390 650 2 0 {name=p149 sig_type=std_logic lab=d12}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 -30 0 0 {name=x1}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 40 0 0 {name=x2}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 110 0 0 {name=x3}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 180 0 0 {name=x4}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 250 0 0 {name=x5}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 320 0 0 {name=x6}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 390 0 0 {name=x7}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 460 0 0 {name=x8}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 530 0 0 {name=x9}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 600 0 0 {name=x10}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 670 0 0 {name=x11}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 740 0 0 {name=x12}
C {/foss/designs/CHIP-PLL/divider/schematics/XNOR.sym} -30 810 0 0 {name=x13}
C {/foss/designs/CHIP-PLL/divider/schematics/NAND_3in.sym} 460 310 0 0 {name=x17}
C {/foss/designs/CHIP-PLL/divider/schematics/NAND_3in.sym} 460 210 0 0 {name=x14}
C {/foss/designs/CHIP-PLL/divider/schematics/NAND_3in.sym} 460 110 0 0 {name=x18}
C {/foss/designs/CHIP-PLL/divider/schematics/NAND_3in.sym} 460 10 0 0 {name=x19}
C {/foss/designs/CHIP-PLL/divider/schematics/NOR_2in.sym} 880 50 0 0 {name=x15}
C {/foss/designs/CHIP-PLL/divider/schematics/NOR_2in.sym} 890 330 0 0 {name=x16}
C {lab_pin.sym} 1040 30 2 0 {name=p94 sig_type=std_logic lab=VP}
C {lab_pin.sym} 1040 50 2 0 {name=p95 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1490 160 1 0 {name=p150 sig_type=std_logic lab=VP}
C {lab_pin.sym} 1490 240 3 0 {name=p151 sig_type=std_logic lab=GND}
C {lab_pin.sym} 1420 160 2 0 {name=p152 sig_type=std_logic lab=VP}
C {lab_pin.sym} 1420 180 2 0 {name=p153 sig_type=std_logic lab=GND}
C {/foss/designs/CHIP-PLL/divider/schematics/NAND_3in.sym} 1260 180 0 0 {name=x20}
C {/foss/designs/CHIP-PLL/divider/schematics/inverter.sym} 1490 200 0 0 {name=x21}
